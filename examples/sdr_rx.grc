options:
  parameters:
    author: artis
    generate_options: qt_gui
    id: sdr_rx
    output_language: python
    run_options: run
    title: sdr_rx
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/artis/Desktop/test.bin
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/artis/Desktop/teksts.txt
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '40'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_1
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: chat_modem_pdu_correlate_0
  id: chat_modem_pdu_correlate
  parameters:
    print_corr: 'False'
    sync_word: '114'
  states: {}
- name: chat_modem_pdu_print_ascii_0
  id: chat_modem_pdu_print_ascii
  parameters: {}
  states: {state: disabled}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '10'
  states: {}
- name: freq_xlating_fir_filter_xxx_0_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 0e3
    decim: '1'
    samp_rate: samp_rate
    taps: firdes.low_pass(1.0,samp_rate,10e3,100)
    type: ccc
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: '32768'
    frequency: int(433.6e6)
    gain1: '''slow_attack'''
    manual_gain1: '60'
    quadrature: 'False'
    rfdc: 'True'
    samplerate: int(samp_rate2)
    uri: ip:pluto.local
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    name: '"rx bits"'
    ncols: '40'
    nrows: '256'
    samp_rate: samp_rate
    type: byte
    update_time: '0.010'
  states: {}
- name: qtgui_time_raster_sink_x_0_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    name: '"rx bits sync"'
    ncols: '40'
    nrows: '256'
    samp_rate: samp_rate
    type: byte
    update_time: '0.010'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: rational_resampler_xxx_1_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate2)
    interp: int(samp_rate)
    taps: ''
    type: ccc
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_unpacked_to_packed_xx_1, '0']
- [blocks_pdu_to_tagged_stream_0, '0', qtgui_time_raster_sink_x_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, chat_modem_pdu_correlate_0, msg_in]
- [blocks_tagged_stream_to_pdu_0_0, pdus, chat_modem_pdu_print_ascii_0, msg_in]
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [blocks_unpacked_to_packed_xx_1, '0', blocks_file_sink_0_0, '0']
- [chat_modem_pdu_correlate_0, msg_out, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_gmsk_demod_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [digital_gmsk_demod_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_gmsk_demod_0, '0', qtgui_time_raster_sink_x_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', digital_gmsk_demod_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_freq_sink_x_0_0, '0']
- [freq_xlating_fir_filter_xxx_0_0, '0', qtgui_time_sink_x_0, '0']
- [iio_pluto_source_0, '0', rational_resampler_xxx_1_0, '0']
- [rational_resampler_xxx_1_0, '0', freq_xlating_fir_filter_xxx_0_0, '0']

metadata:
  file_format: 1
