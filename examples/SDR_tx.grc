options:
  parameters:
    author: artis
    generate_options: qt_gui
    id: SDR_tx
    output_language: python
    title: SDR_tx
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: '9600'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 48e3
  states: {}
- name: samp_rate2
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("a")
    period: '8'
  states: {}
- name: chat_modem_pdu_char_to_ascii_0
  id: chat_modem_pdu_char_to_ascii
  parameters:
    packet_len: '32'
  states: {}
- name: chat_modem_pdu_char_to_ascii_0_0
  id: chat_modem_pdu_char_to_ascii
  parameters:
    packet_len: '32'
  states: {}
- name: chat_modem_pdu_frame_format_0
  id: chat_modem_pdu_frame_format
  parameters:
    packet_len: '40'
    repeat: '10'
    sync_word: '114'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '10'
    verbose: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '30'
    freq0: int(433.6e6)
    gain0: '30'
    if_gain0: '30'
    sample_rate: samp_rate2
    sync: sync
    type: fc32
  states: {}
- name: pdu_utils_pdu_to_bursts_X_0
  id: pdu_utils_pdu_to_bursts_X
  parameters:
    depth: '64'
    early_behavior: pdu_utils.EARLY_BURST_BEHAVIOR__APPEND
    type: b
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    type: string
    value: a
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate2
    ctrlpanel: 'True'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    gui_hint: tab@1
    size: '20000'
    srate: samp_rate2
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: int(samp_rate)
    interp: int(samp_rate2)
    taps: ''
    type: ccc
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0
    label0: msg
    label1: time
    label2: freq
    num_tabs: '3'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: '2'
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: '1'
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: '2'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, chat_modem_pdu_char_to_ascii_0_0, msg_in]
- [chat_modem_pdu_char_to_ascii_0, msg_out, chat_modem_pdu_frame_format_0, msg_in]
- [chat_modem_pdu_char_to_ascii_0_0, msg_out, chat_modem_pdu_frame_format_0, en]
- [chat_modem_pdu_frame_format_0, msg_out, pdu_utils_pdu_to_bursts_X_0, bursts]
- [digital_gmsk_mod_0, '0', virtual_sink_1, '0']
- [pdu_utils_pdu_to_bursts_X_0, '0', virtual_sink_0, '0']
- [qtgui_edit_box_msg_0, msg, chat_modem_pdu_char_to_ascii_0, msg_in]
- [rational_resampler_xxx_0, '0', osmosdr_sink_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_0, '0']
- [virtual_source_0, '0', digital_gmsk_mod_0, '0']
- [virtual_source_1, '0', rational_resampler_xxx_0, '0']

metadata:
  file_format: 1
