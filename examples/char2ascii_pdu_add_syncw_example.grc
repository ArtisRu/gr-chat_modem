options:
  parameters:
    author: artis
    generate_options: qt_gui
    id: char2ascii_pdu_add_syncw_example
    output_language: python
    title: char2ascii_pdu_add_syncw_example
  states: {}

blocks:
- name: qpsk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/artis/Downloads/pdu_char2ascii_add_sync.bin
    type: byte
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(chr(170))
    period: '10'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: chat_modem_pdu_add_sync_word_0
  id: chat_modem_pdu_add_sync_word
  parameters:
    sync_word: '114'
  states: {}
- name: chat_modem_pdu_char_to_ascii_0
  id: chat_modem_pdu_char_to_ascii
  parameters:
    packet_len: '16'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    type: string
    value: a
  states: {}

connections:
- [blocks_message_strobe_0, strobe, chat_modem_pdu_char_to_ascii_0, msg_in]
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [chat_modem_pdu_add_sync_word_0, msg_out, blocks_pdu_to_tagged_stream_0, pdus]
- [chat_modem_pdu_char_to_ascii_0, msg_out, chat_modem_pdu_add_sync_word_0, msg_in]
- [qtgui_edit_box_msg_0, msg, chat_modem_pdu_char_to_ascii_0, msg_in]

metadata:
  file_format: 1
