options:
  parameters:
    author: artis
    generate_options: qt_gui
    id: pdu_frame_format_test
    output_language: python
    title: pdu_frame_format_test
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern(chr(170))
    period: '250'
  states: {}
- name: chat_modem_pdu_char_to_ascii_0
  id: chat_modem_pdu_char_to_ascii
  parameters:
    packet_len: 64-8
  states: {}
- name: chat_modem_pdu_char_to_ascii_0_0
  id: chat_modem_pdu_char_to_ascii
  parameters:
    packet_len: 64-8
  states: {}
- name: chat_modem_pdu_frame_format_0
  id: chat_modem_pdu_frame_format
  parameters:
    packet_len: '64'
    sync_word: '114'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    type: string
    value: a
  states: {}

connections:
- [blocks_message_strobe_0, strobe, chat_modem_pdu_char_to_ascii_0_0, msg_in]
- [chat_modem_pdu_char_to_ascii_0, msg_out, chat_modem_pdu_frame_format_0, msg_in]
- [chat_modem_pdu_char_to_ascii_0_0, msg_out, chat_modem_pdu_frame_format_0, en]
- [chat_modem_pdu_frame_format_0, msg_out, blocks_message_debug_0, print_pdu]
- [qtgui_edit_box_msg_0, msg, chat_modem_pdu_char_to_ascii_0, msg_in]

metadata:
  file_format: 1
