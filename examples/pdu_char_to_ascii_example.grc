options:
  parameters:
    author: artis
    generate_options: qt_gui
    id: pdu_char_to_ascii_example
    output_language: python
    title: pdu_char_to_ascii_example
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/artis/Desktop/pdu_char2ascii.bin
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: chat_modem_pdu_char_to_ascii_0
  id: chat_modem_pdu_char_to_ascii
  parameters:
    packet_len: '16'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    is_pair: 'False'
    is_static: 'False'
    type: string
    value: a
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', blocks_file_sink_0, '0']
- [chat_modem_pdu_char_to_ascii_0, msg_out, blocks_pdu_to_tagged_stream_0, pdus]
- [qtgui_edit_box_msg_0, msg, chat_modem_pdu_char_to_ascii_0, msg_in]

metadata:
  file_format: 1
